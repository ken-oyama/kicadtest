File: kicadtest.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U1 7402, U2 74HC7014

Commit message: added
Parts:
- added U3: 74AHC04, symbol 74xx:74AHC04
